# IAR project LiveTune.ewp, settings and files
configuration Designer (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573II ST STM32H573II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32H5; STM32H573xx; USE_BLE_SPEAKER; USE_FREERTOS; USE_THREADS; USE_CMSISOS_V2; USE_HAL_DRIVER; TUD_AUDIO_IN_USED_no; TUD_AUDIO_OUT_USED_no; CFG_TUD_MIDI_IN=1; AUDIO_CHAIN_ACSDK_USED; AUDIO_CHAIN_CONF_TUNING_CLI_USED; AUDIO_MEM_CONF_TRACK_MALLOC; AUDIO_ASSERT_ENABLED; STACK_MONITORING; FLOATING_POINT; USE_SMALLFT; OS_SUPPORT_CUSTOM; USE_LIVETUNE_DESIGNER; ST_USE_DEBUG; ST_USE_PMEM; BUILD_REDUCED_LOG_MESSAGE; AUDIO_BUILD_RELEASE; ST_NO_FLASHEXT; USE_UART; USE_UART_OVER_USB
  ICCARM.CCDiagSuppress: PA205,Pe188,pe084
  ICCARM.CCIncludePath2: ../../../../../Middlewares/ST/Audio-Kit/examples/usecases/livetune/Conf; ../Common/Core/Inc; ../Common/Core/Conf; ../Platform/Conf; ../Platform/Patch; ../Common/RTOS/Inc; ../Common/tinyUsb; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/CMSIS/DSP/Include; ../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../Drivers/BSP/Components/Common; ../../../../../Drivers/BSP/BLE_Speaker; ../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../Middlewares/ST/AudioBuffer/Inc; ../../../../../Middlewares/ST/Audio-Kit/src/acsdk; ../../../../../Middlewares/ST/Audio-Kit/src/algos; ../../../../../Middlewares/ST/Audio-Kit/src/algos/speex_aec; ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Collections; ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Interface; ../../../../../Middlewares/ST/Audio-Kit/src/helpers; ../../../../../Middlewares/ST/Audio-Kit/lib; ../../../../../Middlewares/ST/STM32_Audio/Addons/Common/Inc; ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc; ../../../../../Middlewares/ST/STM32_Audio/STM32_AcousticBF_Library/Inc; ../../../../../Middlewares/Third_Party/Audio/SpeexDsp/include; ../../../../../Middlewares/Third_Party/Audio/SpeexDsp/libspeexdsp; ../../../../../Middlewares/Third_Party/TinySoundFont; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../Middlewares/Third_Party/tinyusb/src; ../../../../../Middlewares/Third_Party/tinyusb; ../../../../../Utilities/Audio/Inc; ../../../../../Utilities/CyclesCnt; ../../../../../Utilities/STJson; ../../../../../Utilities/STFlashStorage; ../../../../../Utilities/STOs; ../../../../../Utilities/STOs/iar; ../../../../../Utilities/STPmem; ../../../../../Utilities/Traces; ../../../../../Utilities/Terminal
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: STM32H5; BUILD_REDUCED_LOG_MESSAGE; AUDIO_BUILD_RELEASE
  AARM.AUserIncludes: ../../../../../Middlewares/ST/Audio-Kit/examples/usecases/livetune/Conf; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: firmware.hex
  ILINK.IlinkOutputFile: LiveTune.out
  ILINK.IlinkIcfFile: stm32h573xx_flash.icf
  ILINK.IlinkExtraOptions: --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32H5; STM32H573xx; USE_BLE_SPEAKER; USE_FREERTOS; USE_THREADS; USE_CMSISOS_V2; USE_HAL_DRIVER; TUD_AUDIO_IN_USED_no; TUD_AUDIO_OUT_USED_no; CFG_TUD_MIDI_IN=1; AUDIO_CHAIN_ACSDK_USED; AUDIO_CHAIN_RELEASE; ST_USE_PMEM; RTOS_BACKGROUND_TASK_ENABLE=0U; ALGO_USE_LIST; FLOATING_POINT; USE_SMALLFT; OS_SUPPORT_CUSTOM; BUILD_REDUCED_LOG_MESSAGE; AUDIO_BUILD_RELEASE; ST_NO_FLASHEXT; LOWPWR; configUSE_IDLE_HOOK=1
  group Drivers/BSP
    ../../../../../Drivers/BSP/BLE_Speaker/: BLE_Speaker_H5_bsp_audio.c BLE_Speaker_H5_bsp_com.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/DSP/Lib/IAR/: libCMSISDSP_cortex-m33_FFTmax2048.a
    ../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i2s.c stm32h5xx_hal_icache.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_sai.c stm32h5xx_hal_sai_ex.c stm32h5xx_hal_sdram.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_xspi.c stm32h5xx_ll_dlyb.c stm32h5xx_ll_fmc.c stm32h5xx_ll_usb.c
  group Middlewares/ST/Audio-Kit/Examples/usecases/livetune/Conf
    ../../../../../Middlewares/ST/Audio-Kit/examples/usecases/livetune/Conf/: audio_chain_instance_conf.h audio_chain_tasks_conf.h FreeRTOSConfig.h livetune_db_conf.h livetuneConf.h platform_setup_conf.h st_ac_types.h st_message_conf.h st_os_conf.h st_registry_conf.h stm32_audio_capture_conf.h traces_conf.h
  group Middlewares/ST/Audio-Kit/Examples/usecases/livetune/Src
    ../../../../../Middlewares/ST/Audio-Kit/examples/usecases/livetune/Src/: ac_algos_list.c audio_chain_generated_code.c wrapper_audio_chain.c
  group Middlewares/ST/Audio-Kit/Lib
    ../../../../../Middlewares/ST/Audio-Kit/lib/: acSdk.h audio_algo.h audio_algo_list.h audio_algo_tuning.h audio_algo_typedef.h audio_capabilities.h audio_chain.h audio_chain_all_algos.h audio_chain_factory.h audio_chain_utilities.h audio_chain_version.h audio_chunk.h audio_chunk_list.h audio_descriptor.h g711_st.h sfc.h
  group Middlewares/ST/Audio-Kit/Lib/Iar
    ../../../../../Middlewares/ST/Audio-Kit/lib/: AudioChain_CM33_IAR.a AudioChainAlgos_CM33_IAR.a
  group Middlewares/ST/Audio-Kit/Src/acSdk
    ../../../../../Middlewares/ST/Audio-Kit/src/acsdk/: acSdk.c
  group Middlewares/ST/Audio-Kit/Src/Algos/acousticbf
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/acousticbf/: audio_chain_acousticBF_cardoid_factory.c audio_chain_acousticBF_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/acousticbf/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/acousticbf/src/wrapper/: audio_chain_acousticBF.c audio_chain_acousticBF_cardoid.c
  group Middlewares/ST/Audio-Kit/Src/Algos/capture
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/capture/: audio_chain_capture_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/capture/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/capture/src/wrapper/: audio_chain_capture.c
  group Middlewares/ST/Audio-Kit/Src/Algos/cic
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/cic/: audio_chain_cic_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/cic/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/cic/src/wrapper/: audio_chain_cic.c
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/cic/src/: cic.c
  group Middlewares/ST/Audio-Kit/Src/Algos/Common
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/common/Src/: biquad.c commonMath.c fir.c FIR_DC_remove_highpass_coef.c FIR_resampling_lowpass_coef.c IIR_high_pass_coef.c IIR_low_pass_coef.c IIR_noise_bandpass_coef.c IIR_voice_bandpass_coef.c speexAlloc.c util.c
  group Middlewares/ST/Audio-Kit/Src/Algos/constantsource
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/constantsource/: audio_chain_constantSource_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/constantsource/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/constantsource/src/wrapper/: audio_chain_constantSource.c
  group Middlewares/ST/Audio-Kit/Src/Algos/deinterleave
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/deinterleave/: audio_chain_deinterleave_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/deinterleave/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/deinterleave/src/wrapper/: audio_chain_deinterleave.c
  group Middlewares/ST/Audio-Kit/Src/Algos/delay
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/delay/: audio_chain_delay_factory.c audio_chain_delay_samples_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/delay/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/delay/src/wrapper/: audio_chain_delay.c audio_chain_delay_samples.c
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/delay/src/: delay.c
  group Middlewares/ST/Audio-Kit/Src/Algos/disto
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/disto/: audio_chain_disto_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/disto/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/disto/src/wrapper/: audio_chain_disto.c
  group Middlewares/ST/Audio-Kit/Src/Algos/echo
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/echo/: audio_chain_echo_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/echo/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/echo/src/wrapper/: audio_chain_echo.c
  group Middlewares/ST/Audio-Kit/Src/Algos/faust
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/faust/: audio_chain_faust_compressor.h audio_chain_faust_compressor_factory.c audio_chain_faust_distortion.h audio_chain_faust_distortion_factory.c audio_chain_faust_flanger.h audio_chain_faust_flanger_factory.c audio_chain_faust_noise_gate.h audio_chain_faust_noise_gate_factory.c audio_chain_faust_phaser.h audio_chain_faust_phaser_factory.c audio_chain_faust_reverb_dattorro.h audio_chain_faust_reverb_dattorro_factory.c audio_chain_sound_chorus.h audio_chain_sound_chorus_factory.c audio_faust_compressor.h audio_faust_distortion.h audio_faust_flanger.h audio_faust_noise_gate.h audio_faust_phaser.h audio_faust_reverb_dattorro.h sound_chorus_config.h
  group Middlewares/ST/Audio-Kit/Src/Algos/faust/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/faust/src/wrapper/: audio_chain_faust_compressor.c audio_chain_faust_distortion.c audio_chain_faust_flanger.c audio_chain_faust_noise_gate.c audio_chain_faust_phaser.c audio_chain_faust_reverb_dattorro.c audio_chain_sound_chorus.c
  group Middlewares/ST/Audio-Kit/Src/Algos/faust/src/soundlib
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/faust/src/wrapper/soundLibs/: WaveGenerator.c WaveGenerator.h
  group Middlewares/ST/Audio-Kit/Src/Algos/fbeamforming
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fBeamforming/: audio_chain_fbeamforming_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fdisjoin
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fdisjoin/: audio_chain_fdisjoin_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fdisjoin/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fdisjoin/src/wrapper/: audio_chain_fdisjoin.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fir_equalizer
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fir_equalizer/: audio_chain_FIR_equalizer_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fir_graphic_equalizer
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fir_graphic_equalizer/: audio_chain_FIR_graphic_equalizer_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fjoin
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fjoin/: audio_chain_fjoin_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fjoin/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fjoin/src/wrapper/: audio_chain_fjoin.c
  group Middlewares/ST/Audio-Kit/Src/Algos/fnlms
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/fnlms/: audio_chain_fnlms_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/g711
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/g711/: audio_chain_g711_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/g711/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/g711/src/wrapper/: audio_chain_g711_dec.c audio_chain_g711_enc.c
  group Middlewares/ST/Audio-Kit/Src/Algos/gain
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/gain/: audio_chain_gain_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/gain/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/gain/src/wrapper/: audio_chain_gain.c
  group Middlewares/ST/Audio-Kit/Src/Algos/hpf
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/hpf/: audio_chain_hpf_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/hpf/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/hpf/src/wrapper/: audio_chain_hpf.c
  group Middlewares/ST/Audio-Kit/Src/Algos/iir_equalizer
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/iir_equalizer/: audio_chain_IIR_equalizer_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/interleave
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/interleave/: audio_chain_interleave_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/interleave/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/interleave/src/wrapper/: audio_chain_interleave.c
  group Middlewares/ST/Audio-Kit/Src/Algos/linear_mix
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/linear_mix/: audio_chain_linear_mix_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/linear_mix/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/linear_mix/src/wrapper/: audio_chain_linear_mix.c
  group Middlewares/ST/Audio-Kit/Src/Algos/mdrc
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/mdrc/: audio_chain_mdrc_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/mix
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/mix/: audio_chain_mix_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/mix/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/mix/src/wrapper/: audio_chain_mix.c
  group Middlewares/ST/Audio-Kit/Src/Algos/mono2stereo
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/mono2stereo/: audio_chain_mono2stereo_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/mono2stereo/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/mono2stereo/src/wrapper/: audio_chain_mono2stereo.c
  group Middlewares/ST/Audio-Kit/Src/Algos/nlms
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/nlms/: audio_chain_nlms_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/nlms/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/nlms/src/wrapper/: audio_chain_nlms.c
  group Middlewares/ST/Audio-Kit/Src/Algos/nr
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/nr/: audio_chain_nr_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/passthrough
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/passthrough/: audio_chain_passThrough_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/passthrough/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/passthrough/src/wrapper/: audio_chain_passThrough.c
  group Middlewares/ST/Audio-Kit/Src/Algos/pdm2pcm
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/pdm2pcm/: audio_chain_pdm2pcm_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/pdm2pcm/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/pdm2pcm/src/wrapper/: audio_chain_pdm2pcm.c
  group Middlewares/ST/Audio-Kit/Src/Algos/resample
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/resample/: audio_chain_resample_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/resample/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/resample/src/wrapper/: audio_chain_resample.c
  group Middlewares/ST/Audio-Kit/Src/Algos/rms
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/rms/: audio_chain_rms_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/rms/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/rms/src/wrapper/: audio_chain_rms.c
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/rms/src/: rms.c
  group Middlewares/ST/Audio-Kit/Src/Algos/route
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/route/: audio_chain_route_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/route/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/route/src/wrapper/: audio_chain_route.c
  group Middlewares/ST/Audio-Kit/Src/Algos/sam
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/sam/: audio_chain_sam_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/sfc
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/sfc/: audio_chain_sfc_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/sfc/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/sfc/src/wrapper/: audio_chain_sfc.c
  group Middlewares/ST/Audio-Kit/Src/Algos/signal_generator
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/signal_generator/: audio_chain_signal_generator_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/signal_generator/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/signal_generator/src/wrapper/: audio_chain_signal_generator.c
  group Middlewares/ST/Audio-Kit/Src/Algos/sound_font
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/sound_font/: audio_chain_sound_font.h audio_chain_sound_font_factory.c audio_sound_font.h
  group Middlewares/ST/Audio-Kit/Src/Algos/sound_font/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/sound_font/src/wrapper/: audio_chain_sound_font.c
  group Middlewares/ST/Audio-Kit/Src/Algos/spectrum
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/spectrum/: audio_chain_spectrum_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/spectrum/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/spectrum/src/wrapper/: audio_chain_spectrum.c
  group Middlewares/ST/Audio-Kit/Src/Algos/speex_aec
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/speex_aec/: audio_chain_speex_aec_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/speex_aec/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/speex_aec/src/wrapper/: audio_chain_speex_aec.c
  group Middlewares/ST/Audio-Kit/Src/Algos/speex_nr
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/speex_nr/: audio_chain_speex_nr_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/speex_nr/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/speex_nr/src/wrapper/: audio_chain_speex_nr.c
  group Middlewares/ST/Audio-Kit/Src/Algos/split
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/split/: audio_chain_split_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/split/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/split/src/wrapper/: audio_chain_split.c
  group Middlewares/ST/Audio-Kit/Src/Algos/stereo2mono
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/stereo2mono/: audio_chain_stereo2mono_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/stereo2mono/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/stereo2mono/src/wrapper/: audio_chain_stereo2mono.c
  group Middlewares/ST/Audio-Kit/Src/Algos/switch
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/switch/: audio_chain_switch_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/switch/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/switch/src/wrapper/: audio_chain_switch.c
  group Middlewares/ST/Audio-Kit/Src/Algos/voidsink
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/voidsink/: audio_chain_voidSink_factory.c
  group Middlewares/ST/Audio-Kit/Src/Algos/voidsink/src
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/voidsink/src/wrapper/: audio_chain_voidSink.c
  group Middlewares/ST/Audio-Kit/Src/Algos/wola
    ../../../../../Middlewares/ST/Audio-Kit/src/algos/wola/: audio_chain_wola_fwd_factory.c audio_chain_wola_inv_factory.c
  group Middlewares/ST/Audio-Kit/Src/helpers
    ../../../../../Middlewares/ST/Audio-Kit/src/helpers/: algos_memory_usage.c algos_memory_usage.h audio_chain_instance.c audio_chain_instance.h audio_chain_json_from_factory.c audio_chain_json_from_factory.h audio_chain_json_transmission.c audio_chain_json_transmission.h audio_chain_sysIOs_conf.c audio_chain_sysIOs_conf.h audio_chain_tasks_cmsisos.c cycles_measure.c cycles_measure.h stm32_term_acsdk_cmd.c stm32_term_acsdk_tuner.c
  group Middlewares/ST/Audio-Kit/Src/LiveTune
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/: livetune_audio_chain_hook.c livetune_audio_chain_hook.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Collections
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Collections/: st_base.c st_base.h st_message.c st_message.h st_plugin_manager.c st_plugin_manager.h st_registry.c st_registry.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Interface/acFrontEnd
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Interface/: livetune_ac_factory.c livetune_ac_factory.h livetune_ac_json.c livetune_ac_json.h livetune_ac_wrapper.c livetune_ac_wrapper.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Interface/Controller
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Interface/: livetune.c livetune.h livetune_generate.c livetune_generate.h livetune_helper.c livetune_helper.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Interface/livetune_db
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Interface/: livetune_db.c livetune_db.h livetune_db_json.c livetune_db_json.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Interface/livetune_pipe
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Interface/: livetune_pipe.c livetune_pipe.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Plugins/Algos
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Plugins/Algos/: plugin_processing_auto_mount.c
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Plugins/Algos/Interfaced
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Plugins/Algos/Interfaced/: plugin_processing_acousticbf.c plugin_processing_capture.c plugin_processing_IIR_FIR_equalizer.c plugin_processing_rms.c plugin_processing_sam.c plugin_processing_spectrum.c
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Plugins/Algos/NonAcBus
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Plugins/Algos/nonAcBus/: plugin_processing_graph_viewer.c plugin_processing_msg_viewer.c
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Plugins/Algos/SysIo
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Plugins/Algos/SysIo/: plugin_processing_sys_in.c plugin_processing_sys_out.c
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Plugins/Evt
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Plugins/Evt/: plugin_serial_trace.c plugin_serial_trace.h
  group Middlewares/ST/Audio-Kit/Src/LiveTune/Plugins/Evt/Terminal
    ../../../../../Middlewares/ST/Audio-Kit/src/livetune/Plugins/Evt/Terminal/: plugin_terminal_cmd.c plugin_terminal_cmd.h plugin_terminal_cmd_common.c plugin_terminal_cmd_designer.c
  group Middlewares/ST/AudioBuffer
    ../../../../../Middlewares/ST/AudioBuffer/Src/: audio_buffer.c audio_error_mgnt.c audio_mem_mgnt.c
  group Middlewares/ST/STM32_Audio/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM33_IAR_wc32.a
  group Middlewares/ST/STM32_Audio/STM32_AcousticBF_Library
    ../../../../../Middlewares/ST/STM32_Audio/STM32_AcousticBF_Library/Src/: acoustic_bf.c acoustic_bf_cardoid.c acoustic_bf_speex_v1.2.1.c cardoid.c delay.c
  group Middlewares/Third_Party/CMSIS_RTOS_V2
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os.h cmsis_os2.c freertos_mpool.h freertos_os2.h
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/Third_Party/Speex
    ../../../../../Middlewares/Third_Party/Audio/SpeexDsp/libspeexdsp/: fftwrap.c filterbank.c kiss_fft.c kiss_fftr.c mdf.c preprocess.c smallft.c
  group Middlewares/Third_Party/tinyusb/src
    ../../../../../Middlewares/Third_Party/tinyusb/src/: tusb.c tusb.h
  group Middlewares/Third_Party/tinyusb/src/class/audio
    ../../../../../Middlewares/Third_Party/tinyusb/src/class/audio/: audio.h audio_device.c audio_device.h
  group Middlewares/Third_Party/tinyusb/src/class/cdc
    ../../../../../Middlewares/Third_Party/tinyusb/src/class/cdc/: cdc_device.c
  group Middlewares/Third_Party/tinyusb/src/class/hid
    ../../../../../Middlewares/Third_Party/tinyusb/src/class/hid/: hid.h hid_device.c hid_device.h hid_host.c hid_host.h
  group Middlewares/Third_Party/tinyusb/src/class/midi
    ../../../../../Middlewares/Third_Party/tinyusb/src/class/midi/: midi.h midi_device.c midi_device.h
  group Middlewares/Third_Party/tinyusb/src/common
    ../../../../../Middlewares/Third_Party/tinyusb/src/common/: tusb_fifo.c tusb_fifo.h
  group Middlewares/Third_Party/tinyusb/src/device
    ../../../../../Middlewares/Third_Party/tinyusb/src/device/: usbd.c usbd.h usbd_control.c
  group Middlewares/Third_Party/tinyusb/src/portable/st/stm32_fsdev
    ../../../../../Middlewares/Third_Party/tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
  group Middlewares/Third_Party/tinyusb/src/typec
    ../../../../../Middlewares/Third_Party/tinyusb/src/typec/: usbc.c usbc.h
  group Projects/Common/Core
    ../Common/Core/Src/: audio_persist_config.c BoardSetup.c irq_utils.c main.c main_hooks.c ScreenSetup.c voice_announce.c wba_link.c
  group Projects/Common/RTOS
    ../Common/RTOS/Src/: application_hooks_freertos.c background_task.c
  group Projects/Common/RTOS/Inc
    ../Common/RTOS/Inc/: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h
  group Projects/Common/tinyusb
    ../Common/tinyUsb/: plugin_com_usb.c tusb_device.c tusb_hw_config_noos.c usb_descriptors.c
  group Projects/Common/tinyusb/Classes
    ../Common/tinyUsb/: tusb_cdc_vpc0.c tusb_hid_monitor.c tusb_midi_in.c tusb_uac2_audio.c
  group Projects/Common/tinyusb/Inc
    ../Common/tinyUsb/: tinyusb.h tusb_config.h tusb_rb.h usb_descriptors.h
    ../Platform/Conf/: tusb_hw_config.h
  group Projects/EWARM
    ./: copyDelivery.bat startup_stm32h573xx.s stm32h573xx_flash.icf
  group Projects/Platform/Conf
    ../Platform/Conf/: analyze_dbg_conf.h st_flash_storage_conf.h st_os_mem_conf.h stm32_audio_conf.h stm32_usart_conf.h stm32h5xx_hal_conf.h stm32xxx_voice_bsp.h
  group Projects/Platform/LiveTune
    ../Platform/LiveTune/: livetune_hook_hw_conf.c
  group Projects/Platform/Src
    ../Platform/Src/: audio_config.c core_init.c stm32_audio_setup.c stm32h5xx_hal_timebase_tim.c stm32h5xx_it.c
  group Utilities/Audio
    ../../../../../Utilities/Audio/Src/: stm32_audio_tasks_cmsis_os.c
  group Utilities/Audio/Driver
    ../../../../../Utilities/Audio/Src/: stm32_audio.c stm32_audio_dma_h5xx.c stm32_audio_pdm2pcm.c stm32_audio_sai_pdm.c stm32_audio_tinyusb.c
  group Utilities/CyclesCnt
    ../../../../../Utilities/CyclesCnt/: cycles.c
  group Utilities/StFlashStorage
    ../../../../../Utilities/STFlashStorage/: st_flash_storage.c st_flash_storage.h st_flash_storage_template_H5_H7xxx.c
  group Utilities/STJson
    ../../../../../Utilities/STJson/: st_json.c
  group Utilities/STOs
    ../../../../../Utilities/STOs/: st_os.c st_os.h st_os_cmsis_v2.c st_os_compiler_support.c st_os_compiler_support.h st_os_hl.c st_os_hl.h st_os_mem.c st_os_mem.h st_os_monitor_cpu.c st_os_monitor_cpu.h st_os_monitor_cpu_freertos_template.c
  group Utilities/STPmem
    ../../../../../Utilities/STPmem/: st_pmem.c st_pmem.h
  group Utilities/terminal
    ../../../../../Utilities/Terminal/: stm32_term.c stm32_term_cmd.c stm32_term_tasks_cmsis_os.c stm32_term_tasks_noos.c stm32_term_tasks_stos.c stm32_usart.c stm32_usart_h5xx_template.c stm32_usart_lock_cmsis_os.c stm32_usart_lock_noos.c
  group Utilities/Traces
    ../../../../../Utilities/Traces/: traces.c traces2display.c traces2uart.c
