# IAR project BLE_Audio_Broadcast_Speaker.ewp, settings and files
configuration BLE_Audio_Broadcast_Speaker (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; BLE; USE_HAL_DRIVER; STM32WBA65xx; AUDIO_CHAIN_RELEASE; AUDIO_CHAIN_ACSDK_USED; ALGO_USE_LIST
  ICCARM.CCIncludePath2: ../Core/Inc; ../System/Interfaces; ../System/Modules; ../System/Config/Log; ../System/Config/LowPower; ../System/Config/Debug_GPIO; ../System/Config/Flash; ../System/Config/CRC_Ctrl; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Projects/Common/WPAN/Interfaces; ../../../../../../Projects/Common/WPAN/Modules; ../../../../../../Projects/Common/WPAN/Modules/BasicAES; ../../../../../../Projects/Common/WPAN/Modules/Flash; ../../../../../../Projects/Common/WPAN/Modules/MemoryManager; ../../../../../../Projects/Common/WPAN/Modules/RTDebug; ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter; ../../../../../../Projects/Common/WPAN/Modules/Log; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/tim_serv; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_full; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WBA65I-DK1; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/ssd1315; ../../../../../../Drivers/BSP/Components/wm8904; ../../../../../../Middlewares/ST/STM32_WPAN/ble/audio/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/lc3/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/codec_manager/Inc; ../STM32_WPAN/App/AudioUseCases; ../STM32_WPAN/App/AudioUseCases/tmap; ../Core/Src/lcd; ../../../../../../Utilities/LCD; ../../../../../../Middlewares/ST/Audio-Kit/lib; ../../../../../../Middlewares/ST/Audio-Kit/src/helpers; ../../../../../../Middlewares/ST/Audio-Kit/src/livetune/Collections; ../../../../../../Middlewares/ST/Audio-Kit/src/algos; ../../../../../../Utilities/CyclesCnt; ../../../../../../Middlewares/ST/AudioBuffer/Inc; ../../../../../../Utilities/Traces; ../../../../../../Utilities/Audio/Inc; ../../../../../../Drivers/CMSIS/DSP/Include; ../../../../../../Middlewares/ST/Audio-Kit/examples/usecases/livetune/Conf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Audio_TMAP_Peripheral.bin
  ILINK.IlinkOutputFile: BLE_Audio_Broadcast_Speaker.out
  ILINK.IlinkIcfFile: stm32wba65xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: image.c irq_utils.c main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: tmap_app.c app_menu.c app_menu_cfg.c app_bsp.c audio_config.c audio_persist_config.c audiokit_traces_wrapper.c app_ble.c
  group Application/User/STM32_WPAN/App/AudioUseCases
    ../STM32_WPAN/App/AudioUseCases/: usecase_dev_mgmt.c
  group Application/User/STM32_WPAN/App/AudioUseCases/tmap
    ../STM32_WPAN/App/AudioUseCases/tmap/: tmap.c tmap_alloc.c tmap_db.c tmas.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: ble_audio_plat.c ble_audio_if.c ble_codec.c codec_if.c bleplat.c power_table.c linklayer_plat.c bpka.c ll_sys_if.c host_stack_if.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_pka.c hw_pka_p256.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../../Projects/Common/WPAN/Modules/: app_sys.c crc_ctrl.c otp.c scm.c stm_list.c stm_queue.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../../Projects/Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/Log
    ../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../: README.md
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c stm32wba65i_discovery_audio.c stm32wba65i_discovery_bus.c stm32wba65i_discovery_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/Components
    ../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_dma.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Drivers/CMSIS_DSP
    ../../../../../../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
    ../../../../../../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../Drivers/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/audio/lib/: ble_audio.a
  group Middlewares/STM32_WPAN/codec
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/codec_manager/Lib/: codec_mngr.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/lc3/Lib/: LC3.a
  group Middlewares/STM32_WPAN/AudioBuffer
    ../../../../../../Middlewares/ST/AudioBuffer/Src/: audio_buffer.c audio_error_mgnt.c audio_mem_mgnt.c
  group Middlewares/STM32_WPAN/AudioKit
    ../../../../../../Middlewares/ST/Audio-Kit/examples/usecases/livetune/Src/: audio_chain_generated_code.c wrapper_audio_chain.c
    ../../../../../../Middlewares/ST/Audio-Kit/lib/: AudioChain_CM33_IAR.a AudioChainAlgos_CM33_IAR.a
  group Middlewares/STM32_WPAN/acSdk
    ../../../../../../Middlewares/ST/Audio-Kit/src/acsdk/: acSdk.c
  group Middlewares/STM32_WPAN/Algos/FIR_EQ
    ../../../../../../Middlewares/ST/Audio-Kit/src/algos/fir_equalizer/: audio_chain_FIR_equalizer_factory.c
  group Middlewares/STM32_WPAN/Algos/gain
    ../../../../../../Middlewares/ST/Audio-Kit/src/algos/gain/src/wrapper/: audio_chain_gain.c
    ../../../../../../Middlewares/ST/Audio-Kit/src/algos/gain/: audio_chain_gain_factory.c
  group Middlewares/STM32_WPAN/Algos/iir_equalizer
    ../../../../../../Middlewares/ST/Audio-Kit/src/algos/iir_equalizer/: audio_chain_IIR_equalizer_factory.c
  group Middlewares/STM32_WPAN/helpers
    ../../../../../../Middlewares/ST/Audio-Kit/src/helpers/: audio_chain_instance.c audio_chain_sysIOs_conf.c audio_chain_tasks_no_os.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: WBA6_LinkLayer_BLE_Full_lib.a
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Utilities
    ../../../../../../Utilities/LCD/: stm32_lcd.c
    ../../../../../../Utilities/CyclesCnt/: cycles.c
    ../../../../../../Utilities/Audio/Src/: stm32_audio.c
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
